# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MALLOC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE;..\UCOSII\CORE;..\UCOSII\CONFIG;..\UCOSII\PORT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: key.c led.c OLED.c timer.c DL_LN3X_recv.c DL_LN3X_send.c usart3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
